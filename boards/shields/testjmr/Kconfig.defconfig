## boards/shields/testjmr/Kconfig.defconfig
```kconfig
if SHIELD_TESTJMR

config ZMK_KEYBOARD_NAME
    default "testjmr"

endif # SHIELD_TESTJMR
```
